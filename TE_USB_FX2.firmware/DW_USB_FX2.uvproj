# Keil uVision project DW_USB_FX2.uvproj, settings and files
target dw (MCS-51)
  device: EZ-USB FX2 (CY7C68XXX) Cypress Semiconductor
  cpu: IRAM(0 - 0xFF) XRAM(0 - 0x3FF) CLOCK(48000000) MODDP2
  output: usb_dw +hex
  AfterMake: c:\cypress\usb\bin\hex2bix -i -f 0xC2 -o usb_dw.bin usb_dw.hex
  AfterMake: c:\cypress\usb\bin\hex2bix -i -f 0xC2 -o usb_dw.iic usb_dw.hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: fw.c versions.c EZUSB.LIB USBJmpTb.OBJ dscr_dw.a51 te_api.c spi.c i2c.c
