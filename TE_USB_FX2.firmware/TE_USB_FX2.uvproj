# Keil uVision project TE_USB_FX2.uvproj, settings and files
target Target 1 (MCS-51)
  device: EZ-USB FX2 (CY7C68XXX) Cypress Semiconductor
  cpu: IRAM(0 - 0xFF) XRAM(0 - 0x3FF) CLOCK(48000000) MODDP2
  output: FX2_te_usb +hex
  AfterMake: c:\cypress\usb\bin\hex2bix -i -f 0xC2 -o usb.bin FX2_te_usb.hex
  AfterMake: c:\cypress\usb\bin\hex2bix -i -f 0xC2 -o usb.iic FX2_te_usb.hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: dscr.a51 fw.c versions.c i2c.c eeprom.c spi.c isr.c dr.c ep1pool.c
    C:/Cypress/USB/Target/Lib/LP/: EZUSB.LIB USBJmpTb.OBJ
